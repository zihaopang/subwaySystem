# Keil uVision project zm5168_ter.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: zm5168_ter +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\delay;.\UART
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./delay/: delay.c
    ./UART/: UART.c
